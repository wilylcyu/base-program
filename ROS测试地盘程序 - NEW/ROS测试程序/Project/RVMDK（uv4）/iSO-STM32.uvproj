# Keil uVision project iSO-STM32.uvproj, settings and files
target Led (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 流水灯 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\SysTick;..\..\User\PID;..\..\User\contact;..\..\User\UltrasonicWave;..\..\User\spin;..\..\User\encoder;..\..\User\GPIO_conf;..\..\User\NVIC_conf;..\..\User\RCC_Conf;..\..\User\TIM2_5_6;..\..\User\usart;..\..\User\encoder;..\..\User\Delay;..\..\User\Odometry;..\..\User\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/SysTick/: systick.c
    ../../User/PID/: PID.C
    ../../User/contact/: contact.c
    ../../User/Delay/: delay.c
    ../../User/encoder/: encoder.c
    ../../User/GPIO_conf/: gpio_conf.c
    ../../User/NVIC_conf/: nvic_conf.c
    ../../User/RCC_Conf/: rcc_conf.c
    ../../User/TIM2_5_6/: tim2_5_6.c
    ../../User/UltrasonicWave/: UltrasonicWave.c
    ../../User/usart/: usart.c
    ../../User/Odometry/: odometry.c
    ../../User/IWDG/: iwdg.c
  group DOC
    ../../Doc/: readme.txt
